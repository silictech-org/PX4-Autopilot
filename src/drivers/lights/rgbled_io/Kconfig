## src/drivers/lights/rgbled_io/Kconfig
```kconfig
menuconfig DRIVERS_LIGHTS_RGBLED_IO
	bool "rgbled_io"
	default n
	---help---
		Enable support for rgbled_io
```
